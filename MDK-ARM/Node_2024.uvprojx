# Keil uVision project Node_2024.uvprojx, settings and files
target Node_2024 (5060960::V5.06 update 7 (build 960)::.\v5)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Node_2024 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USER_CODE/Adapter;../USER_CODE/Adapter/Common;../USER_CODE/Drivers/Modules/Rtc_User;../USER_CODE/Drivers/Devices/Sx127x;../USER_CODE/Middlewares/Base;../USER_CODE/Utilities/Data_Queue/CircularBuffer_FIFO;../USER_CODE/Utilities/Debug/SerialType1;../USER_CODE/Utilities/Debug/SerialType2;../USER_CODE/Utilities/Serial_Pipe;../USER_CODE/Utilities/Timer_Queue;../USER_CODE/Apps/LoRaMac_Node;../USER_CODE/Apps/Tasks;../USER_CODE/Misc/Systime;../USER_CODE/Misc;../USER_CODE/;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: Node_2024\Node_2024.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c iwdg.c rng.c rtc.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group USER_CODE/Adapter
    ../USER_CODE/Adapter/: gpio_driver.c gpio_driver.h iwdg_driver.c iwdg_driver.h spi1_driver.c spi1_driver.h systick_driver.c systick_driver.h uart1_driver.c uart1_driver.h uart2_driver.c uart2_driver.h
    ../USER_CODE/Adapter/Common/: common.h common.c pinmap.c pinmap.h version.h
  group USER_CODE/Driver/Devices/Sx127x
    ../USER_CODE/Drivers/Devices/Sx127x/: sx127x.c sx127x.h sx127x_Types.h
    ../USER_CODE/Drivers/Devices/Sx127x/cfg/: sx127x_cfg.c sx127x_cfg.h
  group USER_CODE/Utilities/Data_Queue
    ../USER_CODE/Utilities/Data_Queue/CircularBuffer_FIFO/: Circular_Buffer.c Circular_Buffer.h Circular_Buffer_Types.h
    ../USER_CODE/Utilities/Data_Queue/CircularBuffer_FIFO/cfg/: Circular_Buffer_Cfg.c Circular_Buffer_Cfg.h
  group USER_CODE/Apps/LoRaMac_Node
    ../USER_CODE/Apps/LoRaMac_Node/: LoRaMac_Node.c LoRaMac_Node.h LoRaMac_Node_Types.h
    ../USER_CODE/Apps/LoRaMac_Node/cfg/: LoRaMac_Node_Cfg.c LoRaMac_Node_Cfg.h
  group USER_CODE/Apps/Tasks
    ../USER_CODE/Apps/Tasks/: task_InterBoard.cpp task_InterBoard.h task_LoRa.cpp task_LoRa.h task_watchdog.cpp task_watchdog.h
  group USER_CODE/Utilities/Debug/SerialType1
    ../USER_CODE/Utilities/Debug/SerialType1/: debug_hal.c debug_hal.h
  group USER_CODE/Utilities/Debug/SerialType2
    ../USER_CODE/Utilities/Debug/SerialType2/: Serial_Debug.c Serial_Debug.h
  group USER_CODE/Misc
    ../USER_CODE/Misc/: Misc.c Misc.h
  group USER_CODE/Utilities/Serial_Pipe
    ../USER_CODE/Utilities/Serial_Pipe/: pipe_hal.h serial_pipe_hal.cpp serial_pipe_hal.h
software components: CMSIS:CORE 5.6.0
